# Keil uVision project OstrStl.uvproj, settings and files
target STM32F103 Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OstrStl
  c flags: Optim=1
  c define: STM32F10X_MD
  c misc: --exceptions
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Files
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group System Files
    ./: Retarget.c Serial.c
  group Source Files
    ./: OstrSt.cpp
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: OstrStl
  c flags: Optim=1
  c define: STM32F10X_MD
  c misc: --exceptions
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
