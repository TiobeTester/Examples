# Keil uVision project Memory.uvproj, settings and files
target STM32F103 Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Memory
  c flags: Optim=1
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT1: ROM 0x70000000 size 0x10000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x60000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Files
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group System Files
    ./: Retarget.c
  group Source Files
    ./: ExtMem.c Memory.c
  group Documentation
    ./: Abstract.txt
